# Keil uVision project stm32f103c6_demoprj.uvprojx, settings and files
target Demo (6220000::V6.22::ARMCLANG)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103c6_demoprj
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103x6
  c include: ..\source\drv\STM32F1xx_HAL_Driver\Inc;..\source\drv\STM32F1xx_HAL_Driver\Inc\Legacy;..\source\drv\CMSIS\Device\ST\STM32F1xx\Include;..\source\drv\CMSIS\Include;..\source\cfg\hal
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Src
    ../source/src/: main.c
  group System
    ../source/cfg/system/: system_stm32f1xx.c
  group Startup
    ./: startup_stm32f10x_ld.s
